# IAR project THD_Analyzer_stm8s105.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: USE_IAR_HEADER_FILE
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: THD_Analyzer_stm8s105.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: adc.c adc.h comms.c comms.h delay.c delay.h eep.c eep.h i2c_bb.c i2c_bb.h lcd_i2c.c lcd_i2c.h ring_buffer.h scheduler.c scheduler.h stm8_hw_init.c stm8_hw_init.h stm8s105.h THD_Analyzer_main.c THD_Analyzer_main.h tm1637.c tm1637.h uart.c uart.h
